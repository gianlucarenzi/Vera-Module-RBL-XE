# Repository gianlucarenzi/Vera-Module-RBL-XE

File README.md (part):

# VERA Module RBL-XE

<div align="center">

*🌐 English | [🌐 Italiano](#vera-module-rbl-xe-italiano)*

</div>

> [!WARNING]
> **WORK IN PROGRESS — NOT WORKING.**
> This project is under development and does **not** work yet. The board has not been built or
> tested; firmware (ESP32, FPGA) and documentation have only been checked in simulation or on
> paper and may contain errors. Do not manufacture the PCB or rely on this design yet.

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📋 Table of Contents

- [🔍 Overview](#-overview)
- [✨ Features](#-features)
- [⚙️ Technical Specifications](#️-technical-specifications)
- [🔧 Hardware Components](#-hardware-components)
- [🖼️ Board Preview](#️-board-preview)
- [📐 PCB Layers](#-pcb-layers)
- [🔌 Connectors & Interfaces](#-connectors--interfaces)
- [⚡ Power Requirements](#-power-requirements)
- [🔨 Assembly Instructions](#-assembly-instructions)
- [📦 Bill of Materials](#-bill-of-materials)
- [💻 Programming & Configuration](#-programming--configuration)
- [📁 Project Structure](#-project-structure)
- [🤝 Contributing](#-contributing)
- [📄 License](#-license)

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔍 Overview

The **VERA Module RBL-XE** is a sophisticated FPGA-based audio and video 
expansion card designed specifically for **ATARI XE** computers. 
This module brings modern graphics and audio capabilities to classic ATARI systems 
through the **PBI (Parallel Bus Interface)** protocol connectors.

### What is VERA?

**VERA** (Video Enhanced Retro Adapter) is originally designed for the 
Commander X16 computer but has been adapted for ATARI systems. It provides:

- **Advanced Graphics**: Multiple video layers, sprites, and high-resolution modes
- **Enhanced Audio**: Multi-channel digital audio with PCM and PSG capabilities  
- **Modern Connectivity**: VGA output, SD card storage, and USB programming
- **Retro Compatibility**: Integration with ATARI software with simple drivers

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## ✨ Features

### 🎨 Graphics Capabilities

#### Video Output
- **VGA Output**: 640x480 @ 60Hz with analog RGB signals
- **Multiple Layers**: Background, foreground, and sprite layers
- **Color Depth**: 256 colors from a palette of 4096
- **Sprites**: Hardware-accelerated sprite engine
- **Scrolling**: Smooth horizontal and vertical scrolling

#### Audio Features
- **Digital Audio**: High-quality PCM audio output
- **Multi-channel**: Stereo audio
- **Audio Codec**: WM8524 for professional audio quality
- **3.5mm Jack**: Standard audio output connector

### 🔗 System Integration

#### ATARI Compatibility
- **PBI Interface**: Direct connection to ATARI XE systems
- **Memory Mapping**: $D1XX-$DFXX address space
- **Bus Decoder**: Full software address decoding in ESP32 — A0–A15 sampled every PHI2 cycle, no external hardware decoder required
- **Power Management**: Efficient 5V to 3.3V/1.2V conversion

#### Storage & Programming
- **SD Card Slot**: Micro SD for data storage and ROM loading
- **SPI Flash**: 16Mbit W25Q16 for FPGA configuration
- **USB Programming**: CH340 USB-to-serial for easy updates
- **SPI**: Direct FPGA programming interface

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## ⚙️ Technical Specifications

### Core Specifications

| Component | Specification |
|-----------|---------------|
| **FPGA** | Lattice ICE40UP5K-SG48ITR |
| **Microcontroller** | ESP32-S3FN8 |
| **Flash Memory** | W25Q16JVSNIQ (16Mbit) |
| **Audio Codec** | WM8524CGEDT |
| **USB Interface** | CH340T |
| **Power Regulators** | AMS1117-3.3V, AMS1117-1.2V, L7805 |
| **Crystal (VERA board)** | 25 MHz ECS-2033-250-BN (ICE40UP5K reference clock) |
| **Crystal (ESP32-S3)** | 40 MHz external — required; XTAL\_P (QFN56 pin 54) / XTAL\_N (pin 53) |
| **PCB Layers** | 4-layer (Signal/Power/GND/Signal) |
| **Board Size** | TBD mm x TBD mm |

### Electrical Characteristics

| Parameter | Min | Typ | Max | Unit |
|-----------|-----|-----|-----|------|
| **Supply Voltage** | 4.5 | 5.0 | 5.5 | V |
| **Current Consumption** | - | 800 | 1200 | mA |
| **Operating Temperature** | -10 | 25 | 70 | °C |
| **VGA Output Impedance** | - | 75 | - | Ω |
| **Audio Output Level** | - | 2.0 | - | Vrms |

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔧 Hardware Components

### Main Processing Units

#### FPGA - ICE40UP5K
- **Logic Elements**: 5,280 LUTs
- **Memory**: 120 Kbit BRAM, 1 Mbit SPRAM
- **I/O Pins**: 39 user I/O
- **Package**: QFN-48 (7x7mm)
- **Programming**: SPI configuration

#### ESP32-S3FN8
- **CPU**: Dual-core Xtensa LX7 @ 240 MHz
- **Memory**: 8 MB in-package Quad SPI flash, 512 KB SRAM
- **Connectivity**: Wi-Fi 802.11 b/g/n, Bluetooth 5 LE
- **GPIO**: 45 total (38 usable), all bidirectional
- **Package**: QFN-56 (7×7 mm)
- **Crystal**: requires an external **40 MHz crystal** on dedicated analog pins XTAL\_P (QFN56 pin 54) and XTAL\_N (pin 53) — mandatory for PLL startup; see PIN-MAPPING.md § 5
- **Role**: Full software 6502-bus controller — reads A0–A15, PHI2, R/W every cycle and drives EXTSEL\_N, DEV\_SEL\_N, MPD in real time; handles PBI ($D1xx) and CCTL ($D5xx) in a single unified firmware
- **Timing**: hot loop on Core 0 at max FreeRTOS priority (Core 1 only prints the log on Serial), table-driven page decode; control signals asserted via **Dedicated GPIO** Xtensa TIE instructions (`ee.get_gpio_in` / `ee.wr_mask_gpio_out`, 1 CPU cycle) within the 279 ns PHI2-high window of the 1.79 MHz 6502 clock

### Interface Components

#### Audio System
- **Codec**: WM8524CGEDT (24-bit, 192kHz)
- **Interface**: From FPGA digital audio bus
- **Output**: 3.5mm stereo jack
- **SNR**: >100dB

#### Video System
- **Output**: 15-pin VGA connector
- **Resolution**: 640x480 @ 60Hz
- **Colors**: 8-bit RGB (256 colors)
- **Sync**: Separate H/V sync signals

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🖼️ Board Preview

### 3D Renderings

#### Top View

*Top side showing main components and connectors*

#### Bottom View  

*Bottom side with additional components*

#### Cartridge Adapter

*Optional cartridge interface adapter*

### Board Dimensions

- **Length**: TBD mm
- **Width**: TBD mm  
- **Thickness**: 1.6mm (4-layer PCB)
- **Mounting**: Compatible with ATARI XE CART + ECI slots
- **Connectors**: Flat for space efficiency. It needs a custom 3D printed case

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📐 PCB Layers

### Layer Stack-up

#### Layer 1 - Top Copper (F.Cu)

*Component placement and signal routing*

#### Layer 2 - Power Plane (POWER)

*5V, 3.3V, and 1.2V power distribution*

#### Layer 3 - Ground Plane (GND)

*Solid ground plane for signal integrity*

#### Layer 4 - Bottom Copper (B.Cu)

*Additional signal routing and components*

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔌 Connectors & Interfaces

### External Connections

#### ATARI XE Interface
- **Cartridge Connector**: Classic Cartridge Edge Connector 30 pin 
- **ECI Slot**: Enhanced Cartridge Interface 14 pin 
- **Address Range**: $D1XX-$DFXX
- **Signals**: Data bus, address bus, control signals

#### Video Output (J2)
| Pin | Signal | Description |
|-----|--------|-------------|
| 1-3 | RGB | Red, Green, Blue analog signals |
| 13-14 | H/V Sync | Horizontal/Vertical sync |
| 6-10 | GND | Ground connections |
| 11-12 | Audio L/R | Stereo audio output |

#### Storage Interfaces
- **SD Card Slot (J3)**: Micro SD card interface
- **SPI Flash**: On-board 16Mbit storage
- **USB Port (J4)**: Programming and data transfer

> ⚠ **Program the board only when it is unplugged from the Atari.** The board 5 V rail is tied to the
> Atari +5 V (cartridge pin 13, ECI pin 7) without a diode: with the USB cable (J4) or the DC jack (J5)
> connected while the board is in the Atari, the board would power a switched-off Atari or run in
> parallel with its supply. The same applies to the serial monitor: inside the Atari use a USB adapter
> without VBUS. See `VERA-ATARI-HW-REQUIREMENTS.md` §2.11.

### Programming Interfaces

#### ICEPROG Connector (J6)
| Pin | Signal | Function |
|-----|--------|----------|
| 1 | 5V | Power supply |
| 2 | FPGA_CDONE/PULL-UP | FPGA Programmed |
| 3 | FPGA_RESET | FPGA Reset |
| 4 | MISO | SPI data in |
| 5 | MOSI | SPI data out |
| 6 | SCK | SPI clock |
| 7 | SS | SPI select |
| 8 | GND | Ground |

#### Reset & Control
- **Reset Button (SW1)**: ESP32 system reset
- **DIP Switch (SW2)**: Configuration options
- **Status LEDs**: Power, programming, activity indicators

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## ⚡ Power Requirements

### Power Distribution

#### Power Rails
| Rail | Voltage | Current | Components |
|------|---------|---------|------------|
| **5V** | 5.0V ± 5% | 200mA | Input from ATARI, USB |
| **3.3V** | 3.3V ± 3% | 400mA | ESP32, logic, interfaces |
| **1.2V** | 1.2V ± 3% | 300mA | FPGA core voltage |

#### Power Sources
1. **ATARI PBI**: Primary 5V supply from computer
2. **USB**: Alternative 5V for programming/testing
3. **External**: Optional external 5V supply (J5)

#### Power Protection
- **Schottky Diodes**: Reverse polarity protection
- **Ferrite Beads**: EMI filtering
- **Decoupling**: Extensive capacitor network
- **Current Limiting**: Overcurrent protection

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔨 Assembly Instructions

### Component Assembly

#### Assembly Order
1. **SMD Components**: Start with smallest components (0603, 0805)
2. **ICs**: Place all integrated circuits
3. **Connectors**: Install all external connectors
4. **Through-hole**: Add any remaining THT components
5. **Testing**: Verify power rails before first power-on

#### Special Considerations
- **FPGA**: Use proper ESD precautions
- **BGA Components**: Requires professional assembly
- **Thermal Management**: Ensure adequate cooling
- **Impedance Control**: Maintain 50Ω for high-speed signals

### Testing & Validation

#### Power-On Tests
1. **Visual Inspection**: Check for shorts, proper orientation
2. **Power Rails**: Verify all voltages within tolerance
3. **Clock Signals**: Confirm oscillator operation
4. **Communication**: Test SPI, I2C, UART interfaces

#### Functional Tests
1. **FPGA Programming**: Load test bitstream
2. **Video Output**: Verify VGA signal generation
3. **Audio Output**: Test audio codec functionality
4. **ATARI Interface**: Confirm PBI communication protocol

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📦 Bill of Materials

### Component Categories

#### Major Components
- **1x** ICE40UP5K-SG48ITR FPGA
- **1x** ESP32-S3FN8 Microcontroller  
- **1x** W25Q16JVSNIQ SPI Flash
- **1x** WM8524CGEDT Audio Codec
- **1x** CH340T USB Interface

#### Passive Components
- **23x** 1µF Capacitors (1206)
- **20x** 100nF Capacitors (1206)
- **6x** 10µF Capacitors (1206)
- **Various** Resistors (0805/1206)
- **1x** 25 MHz Crystal Oscillator (VERA board — ICE40UP5K reference clock)
- **1x** 40 MHz Crystal + 2×10 pF load capacitors (ESP32-S3 — mandatory)

#### Connectors
- **1x** 15-pin VGA Connector
- **1x** Micro SD Card Slot
- **1x** USB Type-C Connector
- **1x** 3.5mm Audio Jack
- **1x** 8-pin Programming Header

### Cost Analysis

| Category | Estimated Cost | Percentage |
|----------|----------------|------------|
| **FPGA** | $15-20 | 35% |
| **ESP32** | $8-12 | 20% |
| **Connectors** | $5-8 | 15% |
| **Passives** | $3-5 | 10% |
| **PCB** | $8-12 | 20% |
| **Total** | **$39-57** | **100%** |

*Costs are estimates for small quantity production*

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 💻 Programming & Configuration

### FPGA Programming

#### Programming Methods
1. **USB/Serial**: Using FTDI 232H adapter interface with iceprog
2. **SPI Direct**: Direct SPI flash programming

#### Programming Steps
```bash
# Install icestorm toolchain
sudo apt install fpga-icestorm

# Program FPGA via USB (The FPGA bitstream is not provided!)
iceprog vera_module.bin

# Verify programming
iceprog -c
```

#### Development Tools
- **IceStorm**: Open-source FPGA toolchain
- **Yosys**: Verilog synthesis
- **NextPNR**: Place and route
- **KiCad**: PCB design and layout

### ESP32 Configuration

#### ESP32 Firmware
The ESP32-S3FN8 (Core 0 hot loop, Core 1 serial log) handles:
- **Startup sync**: ARESET and CRESET asserted LOW immediately in `setup()` (before `Serial.begin`). `MonitorTask` releases CRESET, polls CDONE until the ICE40UP5K bitstream is loaded (< 100 ms typical, 5 s timeout), then releases ARESET — Atari starts with bus and FPGA already ready
- **Bus Decoding**: Full software decode of A0–A15 sampled on every PHI2 rising edge — no page ambiguity
- **Dedicated GPIO**: Control signals (EXTSEL\_N, DEV\_SEL\_N, MPD) asserted in a single Xtensa TIE instruction (`ee.wr_mask_gpio_out`, 1 CPU cycle) within the 279 ns PHI2-high window
- **Data Bus Drive** *(PBI mode only)*: D0–D7 driven via `GPIO.out` for ROM ($D800–$DFFF) and RAM ($D600–$D7FF) reads; FPGA drives the bus in CCTL mode
- **Debugging**: UART0 on GPIO43 (TX) / GPIO44 (RX), 115200 baud

The operating mode is selected at compile time via `VERA_BOARD_IS_PBI` in `main.cpp`:

| `VERA_BOARD_IS_PBI` | Mode | Active ranges | Selection latch |
|---------------------|------|---------------|-----------------|
| `1` (default) | PBI | $D100–$D1FF, $D600–$D7FF, $D800–$DFFF | write `0x80` to $D1FF |
| `0`           | CCTL | $D500–$D5FF                           | write `0x80` to $D5FF |

The **RAMbo 256 KB** emulator is always compiled in and enabled at runtime via **GPIO 3**
(`PIN_RAMBO_EN`, QFN56 pin 8) — no recompilation needed:

| GPIO 3 at boot | Effect |
|----------------|--------|
| Pull-up 10 kΩ → VCC (HIGH) | RAMbo enabled — 256 KB bank-switched at $4000–$7FFF; PORTB ($D301) bit 4 selects active/inactive |
| Pull-down 10 kΩ → GND (LOW) | RAMbo disabled — $4000–$7FFF not intercepted |

Works in both PBI and CCTL mode. The hot loop snoops both **PBCTL** (`$D303`) and
**PORTB** (`$D301`): writes to `$D301` update the bank-selection register **only when**
PBCTL bit 2 = 1 (output register selected). When bit 2 = 0, `$D301` addresses the PIA
6520 DDR and the write is ignored for bank-switching purposes. `PORTB` initialises to
`0xFF` (RAME = 1, RAMbo inactive); `PBCTL` to `0x00` (bit 2 = 0, DDR exposed).

**Passive snooping vs. active driving — no conflict with the physical 6520.** The real
6520 PIA chip remains fully active on the Atari motherboard and responds to `$D301`/`$D303`
normally. The ESP32 does **not** replace the 6520 — it only snoops those bus cycles
(observes without driving). It only actively drives the data bus and asserts EXTSEL\_N
for the `$4000–$7FFF` window, where the 6520 is not mapped. PBCTL tracking is necessary
precisely because the snooping is passive: from the bus, a DDR write and an Output Register
write to `$D301` are **indistinguishable** — PBCTL state is the only way to tell them apart.

#### Programming ESP32
The firmware is built with **PlatformIO** (install via `pip install platformio`):
```bash
# Build firmware (edit VERA_BOARD_IS_PBI in main.cpp before building)
pio run -e esp32s3fn8

# Flash firmware — connect UART adapter to GPIO43/44
pio run -e esp32s3fn8 --target upload
```

> **Note**: USB CDC is disabled because GPIO 19 (USB D−) and GPIO 20 (USB D+) are reused
> as address lines A7 and A8. Use an external UART adapter on GPIO 43/44.

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📁 Project Structure

The design workflow, from the schematic to the JLCPCB order (stock check, library update, ERC, netlist, PCB and net classes, DRC, `output_job.sh`, files to send), is described in [WORKFLOW.md](WORKFLOW.md) (in Italian, also as [PDF](WORKFLOW.pdf)).

### Repository Organization

```
Vera-Module-RBL-XE/
├── 📄 README.md                    # This documentation
├── 📄 WORKFLOW.md                  # Design workflow, schematic to JLCPCB order
├── 📄 PIN-MAPPING.md               # ESP32-S3 / level-shifter pin mapping
├── 📄 VERA-ATARI-HW-REQUIREMENTS.md # Hardware requirements & bring-up plan (from driver/emulator work)
├── 📄 LICENSE                      # GPL v3 license
├── ⚙️ VERA-MODULE-RBL.pro         # KiCad project file
├── 📄 VERA-MODULE-RBL.sch         # Main schematic
├── 🔧 VERA-MODULE-RBL.kicad_pcb   # PCB layout
├── 📄 VERA-MODULE-RBL.csv         # Bill of materials
├── 🐍 jlcpcb-check-bom.py        # BOM processing script
├── 📁 images/                      # Board images and renders
│   ├── 🖼️ VERA-MODULE-RBL-TOP.png
│   ├── 🖼️ VERA-MODULE-RBL-BOTTOM.png
│   ├── 🖼️ F.Cu-L1.png            # PCB layer images
│   ├── 🖼️ POWER-L2.png
│   ├── 🖼️ GND-L3.png
│   └── 🖼️ B.Cu-L4.png
├── 📁 production/                  # Manufacturing files
│   ├── 📄 *.gbl, *.gtl            # Gerber files
│   ├── 📄 *.drl                   # Drill files
│   └── 📄 *.gbrjob                # Job files
├── 📁 ibom/                       # Interactive BOM
│   └── 🌐 ibom.html
└── 📁 schematics/                 # Individual schematics
    ├── 📄 vera-fpga.sch           # FPGA module
    ├── 📄 busdecoder.sch          # Bus decoder
    ├── 📄 cartridgeInterface.sch   # Cartridge interface
    ├── 📄 vera-fpga-flash.sch     # Flash memory
    └── 📄 powersupply.sch         # Power management
```

### Hardware notes (read before bring-up)

- [`VERA-ATARI-HW-REQUIREMENTS.md`](VERA-ATARI-HW-REQUIREMENTS.md) — what the VERA FPGA
  requires from the bus, open points on this board (U19 output enable, WR hold time,
  push-pull IRQ), the gating logic for the data-bus transceiver output enable,
  reset/configuration sequence and the bring-up test plan.

### Design Files

#### KiCad Files
- **Schematic**: Multi-sheet hierarchical design
- **PCB Layout**: 4-layer board with controlled impedance
- **3D Models**: Custom component models
- **Footprints**: Custom connector footprints

#### Manufacturing Files
- **Gerber Files**: Industry-standard PCB fabrication
- **Drill Files**: NC drill and via specifications  
- **Pick & Place**: SMT assembly coordinates
- **BOM**: Component specifications with LCSC part numbers

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🤝 Contributing

### Development Guidelines

#### Contributing Process
1. **Fork** the repository
2. **Create** a feature branch
3. **Make** your changes
4. **Test** thoroughly
5. **Submit** a pull request

#### Contribution Areas
- **Hardware Design**: PCB layout improvements
- **Firmware**: ESP32 and FPGA code
- **Documentation**: User guides and tutorials
- **Testing**: Validation and verification
- **Software**: Host applications and tools

#### Design Goals
- **Compatibility**: Maintain ATARI XE compatibility
- **Performance**: Optimize for speed and efficiency
- **Reliability**: Ensure robust operation
- **Manufacturability**: Design for production
- **Cost**: Balance features with affordability

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📄 License

This project is licensed under the **GNU General Public License v3.0**.

### License Details

#### Permissions
- ✅ Commercial use
- ✅ Modification
- ✅ Distribution
- ✅ Patent use
- ✅ Private use

#### Limitations
- ❌ Liability
- ❌ Warranty

#### Conditions
- 📄 License and copyright notice
- 📄 State changes
- 📄 Disclose source
- 📄 Same license

For the complete license text, see the [LICENSE](LICENSE) file.

</div>

---

<div style="background: linear-gradient(135deg, #1976d2, #42a5f5); color: white; border-radius: 16px; padding: 32px; margin: 32px 0; box-shadow: 0 8px 24px rgba(25,118,210,0.3); text-align: center;">

## 💙 Support the Project

If you find this project useful, please consider:

🌟 **Starring** the repository  
🐛 **Reporting** issues  
🔧 **Contributing** improvements  
📢 **Sharing** with the community  

---

**Made with ❤️ by RetroBit Lab**

*Bringing modern capabilities to classic computers*

</div>

---

# VERA Module RBL-XE (Italiano)

<div align="center">

*[🌐 English](#vera-module-rbl-xe) | 🌐 Italiano*

</div>

> [!WARNING]
> **LAVORO IN CORSO — NON FUNZIONANTE.**
> Il progetto è in fase di sviluppo e **non** funziona ancora. La scheda non è stata realizzata né
> provata; firmware (ESP32, FPGA) e documentazione sono stati verificati solo in simulazione o sulla
> carta e possono contenere errori. Non produrre il PCB e non fare affidamento su questo progetto.

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📋 Indice

- [🔍 Panoramica](#-panoramica)
- [✨ Caratteristiche](#-caratteristiche)
- [⚙️ Specifiche Tecniche](#️-specifiche-tecniche)
- [🔧 Componenti Hardware](#-componenti-hardware)
- [🖼️ Anteprima Scheda](#️-anteprima-scheda)
- [📐 Layer PCB](#-layer-pcb)
- [🔌 Connettori e Interfacce](#-connettori-e-interfacce)
- [⚡ Requisiti di Alimentazione](#-requisiti-di-alimentazione)
- [🔨 Istruzioni di Assemblaggio](#-istruzioni-di-assemblaggio)
- [📦 Distinta Materiali](#-distinta-materiali)
- [💻 Programmazione e Configurazione](#-programmazione-e-configurazione)
- [📁 Struttura Progetto](#-struttura-progetto)
- [🤝 Contribuire](#-contribuire)
- [📄 Licenza](#-licenza-1)

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔍 Panoramica

Il **VERA Module RBL-XE** è una sofisticata scheda di espansione audio e video 
basata su FPGA, progettata specificamente per i computer **ATARI XE**. 
Questo modulo porta capacità grafiche e audio moderne ai sistemi ATARI classici 
attraverso i connettori cartuccia ed ECI per il supporto del protocollo **PBI (Parallel Bus Interface)**.

### Cos'è VERA?

**VERA** (Video Enhanced Retro Adapter) è originariamente progettato per il 
computer Commander X16 ma è stato adattato per i sistemi ATARI. Fornisce:

- **Grafica Avanzata**: Livelli video multipli, sprite e modalità ad alta risoluzione
- **Audio Migliorato**: Audio digitale multicanale con capacità PCM e PSG
- **Connettività Moderna**: Uscita VGA, storage su scheda SD e programmazione USB
- **Compatibilità Retro**: Integrazione con il software ATARI classico tramite semplici drivers

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## ✨ Caratteristiche

### 🎨 Capacità Grafiche

#### Uscita Video
- **Uscita VGA**: 640x480 @ 60Hz con segnali RGB analogici
- **Livelli Multipli**: Livelli di sfondo, primo piano e sprite
- **Profondità Colore**: 256 colori da una palette di 4096
- **Sprite**: Motore sprite accelerato hardware
- **Scrolling**: Scorrimento orizzontale e verticale fluido

#### Caratteristiche Audio
- **Audio Digitale**: Uscita audio PCM di alta qualità
- **Multicanale**: Audio stereo
- **Codec Audio**: WM8524 per qualità audio professionale
- **Jack 3.5mm**: Connettore uscita audio standard

### 🔗 Integrazione Sistema

#### Compatibilità ATARI
- **Interfaccia PBI**: Connessione diretta ai sistemi ATARI XE/XL
- **Mappatura Memoria**: Spazio indirizzi $D1XX-$DFXX
- **Decodificatore Bus**: Decodifica software completa degli indirizzi nell'ESP32 — A0–A15 campionati ad ogni ciclo PHI2, nessun hardware decoder esterno richiesto
- **Gestione Alimentazione**: Conversione efficiente da 5V a 3.3V/1.2V

#### Storage e Programmazione
- **Slot Scheda SD**: Micro SD per storage dati e caricamento ROM
- **Flash SPI**: 16Mbit W25Q16 per configurazione FPGA
- **Programmazione USB**: CH340 USB-to-serial per aggiornamenti facili
- **SPI**: Interfaccia programmazione FPGA diretta

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## ⚙️ Specifiche Tecniche

### Specifiche Principali

| Componente | Specifica |
|------------|-----------|
| **FPGA** | Lattice ICE40UP5K-SG48ITR |
| **Microcontrollore** | ESP32-S3FN8 |
| **Memoria Flash** | W25Q16JVSNIQ (16Mbit) |
| **Codec Audio** | WM8524CGEDT |
| **Interfaccia USB** | CH340T |
| **Regolatori Alimentazione** | AMS1117-3.3V, AMS1117-1.2V, L7805 |
| **Cristallo (scheda VERA)** | 25 MHz ECS-2033-250-BN (clock di riferimento ICE40UP5K) |
| **Cristallo (ESP32-S3)** | 40 MHz esterno — obbligatorio; XTAL\_P (QFN56 pin 54) / XTAL\_N (pin 53) |
| **Layer PCB** | 4 layer (Segnale/Alimentazione/GND/Segnale) |
| **Dimensioni Scheda** | TBD mm x TBD mm |

### Caratteristiche Elettriche

| Parametro | Min | Tip | Max | Unità |
|-----------|-----|-----|-----|-------|
| **Tensione Alimentazione** | 4.5 | 5.0 | 5.5 | V |
| **Consumo Corrente** | - | 800 | 1200 | mA |
| **Temperatura Operativa** | -10 | 25 | 70 | °C |
| **Impedenza Uscita VGA** | - | 75 | - | Ω |
| **Livello Uscita Audio** | - | 2.0 | - | Vrms |

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔧 Componenti Hardware

### Unità di Elaborazione Principali

#### FPGA - ICE40UP5K
- **Elementi Logici**: 5,280 LUT
- **Memoria**: 120 Kbit BRAM, 1 Mbit SPRAM
- **Pin I/O**: 39 I/O utente
- **Package**: QFN-48 (7x7mm)
- **Programmazione**: Configurazione SPI

#### ESP32-S3FN8
- **CPU**: Dual-core Xtensa LX7 @ 240 MHz
- **Memoria**: 8 MB flash Quad SPI integrata, 512 KB SRAM
- **Connettività**: Wi-Fi 802.11 b/g/n, Bluetooth 5 LE
- **GPIO**: 45 totali (38 usabili), tutti bidirezionali
- **Package**: QFN-56 (7×7 mm)
- **Quarzo**: richiede un **quarzo esterno 40 MHz** sui pin analogici dedicati XTAL\_P (QFN56 pin 54) e XTAL\_N (pin 53) — obbligatorio per il PLL di avvio; vedere PIN-MAPPING.md § 5
- **Ruolo**: Controllore bus 6502 completamente software — campiona A0–A15, PHI2, R/W ad ogni ciclo e pilota EXTSEL\_N, DEV\_SEL\_N, MPD tramite istruzioni **Dedicated GPIO** Xtensa TIE (1 ciclo CPU) nella finestra PHI2-high di 279 ns; gestisce PBI ($D1xx) e CCTL ($D5xx) con un unico firmware unificato

### Componenti Interfaccia

#### Sistema Audio
- **Codec**: WM8524CGEDT (24-bit, 192kHz)
- **Interfaccia**: Audio digitale dalla FPGA con bus dedicato
- **Uscita**: Jack stereo 3.5mm
- **SNR**: >100dB

#### Sistema Video
- **Uscita**: Connettore VGA 15-pin
- **Risoluzione**: 640x480 @ 60Hz
- **Colori**: RGB 8-bit (256 colori)
- **Sync**: Segnali H/V sync separati

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🖼️ Anteprima Scheda

### Rendering 3D

#### Vista Superiore

*Lato superiore mostrando componenti principali e connettori*

#### Vista Inferiore

*Lato inferiore con componenti aggiuntivi*

#### Adattatore Cartuccia

*Adattatore interfaccia cartuccia opzionale*

### Dimensioni Scheda

- **Lunghezza**: TBD mm
- **Larghezza**: TBD mm  
- **Spessore**: 1.6mm (PCB 4-layer)
- **Montaggio**: Compatibile con slot ATARI XE CART + ECI
- **Connettori**: Piatti per efficienza spazio. Necessita di case stampato in 3D

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📐 Layer PCB

### Stack-up Layer

#### Layer 1 - Rame Superiore (F.Cu)

*Posizionamento componenti e routing segnali*

#### Layer 2 - Piano Alimentazione (POWER)

*Distribuzione alimentazione 5V, 3.3V e 1.2V*

#### Layer 3 - Piano Massa (GND)

*Piano massa solido per integrità segnale*

#### Layer 4 - Rame Inferiore (B.Cu)

*Routing segnali aggiuntivo e componenti*

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔌 Connettori e Interfacce

### Connessioni Esterne

#### Interfaccia ATARI
- **Connettore PBI**: Connettore edge 50-pin
- **Slot ECI**: Enhanced Cartridge Interface
- **Range Indirizzi**: $D1XX-$DFXX
- **Segnali**: Bus dati, bus indirizzi, segnali controllo

#### Uscita Video (J2)
| Pin | Segnale | Descrizione |
|-----|---------|-------------|
| 1-3 | RGB | Segnali analogici Rosso, Verde, Blu |
| 13-14 | H/V Sync | Sync orizzontale/verticale |
| 6-10 | GND | Connessioni massa |
| 11-12 | Audio L/R | Uscita audio stereo |

#### Interfacce Storage
- **Slot Scheda SD (J3)**: Interfaccia scheda Micro SD
- **Flash SPI**: Storage on-board 16Mbit
- **Porta USB (J4)**: Programmazione e trasferimento dati

### Interfacce Programmazione

#### Connettore ICEPROG (J6)
| Pin | Segnale | Funzione |
|-----|--------|----------|
| 1 | 5V | Alimentazione |
| 2 | FPGA_CDONE/PULL-UP | FPGA Programmata |
| 3 | FPGA_RESET | FPGA Reset |
| 4 | MISO | Dati SPI in ingresso |
| 5 | MOSI | Dati SPI in uscita |
| 6 | SCK | Clock SPI |
| 7 | SS | Selezione SPI |
| 8 | GND | Ground |

#### Reset e Controllo
- **Pulsante Reset (SW1)**: Reset sistema ESP32
- **DIP Switch (SW2)**: Opzioni configurazione
- **LED di Stato**: Indicatori alimentazione, programmazione, attività

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## ⚡ Requisiti di Alimentazione

### Distribuzione Alimentazione

#### Rail Alimentazione
| Rail | Tensione | Corrente | Componenti |
|------|----------|----------|------------|
| **5V** | 5.0V ± 5% | 200mA | Ingresso da ATARI, USB |
| **3.3V** | 3.3V ± 3% | 400mA | ESP32, logica, interfacce |
| **1.2V** | 1.2V ± 3% | 300mA | Tensione core FPGA |

#### Sorgenti Alimentazione
1. **PBI ATARI**: Alimentazione 5V primaria dal computer
2. **USB**: 5V alternativo per programmazione/test
3. **Esterno**: Alimentazione 5V esterna opzionale (J5)

#### Protezione Alimentazione
- **Diodi Schottky**: Protezione polarità inversa
- **Perle di Ferrite**: Filtraggio EMI
- **Disaccoppiamento**: Rete estesa di condensatori
- **Limitazione Corrente**: Protezione sovracorrente

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 🔨 Istruzioni di Assemblaggio

### Assemblaggio Componenti

#### Ordine Assemblaggio
1. **Componenti SMD**: Iniziare con componenti più piccoli (0603, 0805)
2. **IC**: Posizionare tutti i circuiti integrati
3. **Connettori**: Installare tutti i connettori esterni
4. **Through-hole**: Aggiungere eventuali componenti THT rimanenti
5. **Test**: Verificare rail alimentazione prima della prima accensione

#### Considerazioni Speciali
- **FPGA**: Usare precauzioni ESD appropriate
- **Componenti BGA**: Richiede assemblaggio professionale
- **Gestione Termica**: Assicurare raffreddamento adeguato
- **Controllo Impedenza**: Mantenere 50Ω per segnali alta velocità

### Test e Validazione

#### Test Accensione
1. **Ispezione Visiva**: Controllare cortocircuiti, orientamento corretto
2. **Rail Alimentazione**: Verificare tutte le tensioni entro tolleranza
3. **Segnali Clock**: Confermare funzionamento oscillatore
4. **Comunicazione**: Testare interfacce SPI, I2C, UART

#### Test Funzionali
1. **Programmazione FPGA**: Caricare bitstream di test
2. **Uscita Video**: Verificare generazione segnale VGA
3. **Uscita Audio**: Testare funzionalità codec audio
4. **Interfaccia ATARI**: Confermare comunicazione con protocollo PBI

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 📦 Distinta Materiali

### Categorie Componenti

#### Componenti Principali
- **1x** ICE40UP5K-SG48ITR FPGA
- **1x** ESP32-S3FN8 Microcontrollore
- **1x** W25Q16JVSNIQ Flash SPI
- **1x** WM8524CGEDT Codec Audio
- **1x** CH340T Interfaccia USB

#### Componenti Passivi
- **23x** Condensatori 1µF (1206)
- **20x** Condensatori 100nF (1206)
- **6x** Condensatori 10µF (1206)
- **Vari** Resistori (0805/1206)
- **1x** Oscillatore Cristallo 25 MHz (scheda VERA — clock di riferimento ICE40UP5K)
- **1x** Quarzo 40 MHz + 2×10 pF condensatori di carico (ESP32-S3 — obbligatorio)

#### Connettori
- **1x** Connettore VGA 15-pin
- **1x** Slot Scheda Micro SD
- **1x** Connettore USB Type-C
- **1x** Jack Audio 3.5mm
- **1x** Header Programmazione 8-pin

### Analisi Costi

| Categoria | Costo Stimato | Percentuale |
|-----------|---------------|-------------|
| **FPGA** | $15-20 | 35% |
| **ESP32** | $8-12 | 20% |
| **Connettori** | $5-8 | 15% |
| **Passivi** | $3-5 | 10% |
| **PCB** | $8-12 | 20% |
| **Totale** | **$39-57** | **100%** |

*I costi sono stime per produzione piccole quantità*

</div>

---

<div style="background: #ffffff; border-radius: 16px; padding: 24px; margin: 24px 0; box-shadow: 0 4px 12px rgba(0,0,0,0.1); border: 1px solid #e0e0e0;">

## 💻 Programmazione e Configurazione

### Programmazione FPGA

#### Metodi Programmazione
1. **USB/Seriale**: Usando interfaccia FTDI 232H per SPI USB con iceprog
2. **SPI Diretto**: Programmazione flash SPI diretta

#### Passi Programmazione
```bash
# Installare toolchain icestorm
sudo apt install fpga-icestorm

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
## KiCad design VERA-MODULE-RBL.kicad_pcb

Schematic: VERA-MODULE-RBL.sch, VERA FPGA Audio & Video Board

Parts:
FID1, FID2, FID3, FID4: Fiducial; Fiducial_0.5mm_Mask1mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
LBL1: Label-20mmx10mm; Label-20mmx10mm-Silkscreen
LOGO1: VERA X16 LOGO; x16logo
LOGO2: ATARI READY; atari_ready_8mm_rev
LOGO3: KiCAD DESIGN; KiCad-Logo2_6mm_SilkScreen
LOGO4: ATARI DUO BUS; DUOCart_20x11_Rev
LOGO5: ESP32_BOBOARD; ESP32_BOBOARD_5V_21.7mmx21.7mm

Notes on the sheet:
VERA FPGA
BUS DECODER
CARTRIDGE INTERFACE
VERA SPI FLASH SD CARD INTERFACE
POWER SUPPLY
FIDUCIAL TOP
FIDUCIAL BOTTOM
VGA ANALOG

Schematic: vera-fpga.sch, VERA MODULE AND PROGRAMMING CONNECTOR

Parts:
C3, C4, C5, C6, C7, C8, C59, C60: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C2798196
J6: CONN_SMD_01x08_Staggered_2.54mm; PinSocket_1x08_P2.54mm_Vertical_SMD_Pin1Right; LCSC C42380985
JP1, JP3: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
LD2: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C84260
Q1: MOSFET-BSS138-SOT-23; SOT-23; LCSC C82045
R1: 2K7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C313926
R3, R4: 50R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C2828866
R5, R62, R63: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C84376
U2: ICE40UP5K-SG48ITR; QFN-48-1EP_7x7mm_P0.5mm_EP5.6x5.6mm; LCSC C2678152
X1: ECS-2033-250-BN; OSC_ECS-2033-250-BN; PARTREV 11/15/13; LCSC C2441279

Connections:
1V2: C7.1, C8.1, C60.1, U2.5, U2.29, U2.30; also elsewhere on the board
3V3: C3.2, C4.1, C5.1, C6.1, C59.2, JP3.1, LD2.2 (A), R62.1, R63.1, U2.1, U2.22, U2.24, U2.33, X1.4; also elsewhere on the board
5V: JP1.1; also elsewhere on the board
ASYSCLK: R4.1; also elsewhere on the board
AUDIO_BCK: U2.38; also elsewhere on the board
AUDIO_DATA: U2.42; also elsewhere on the board
AUDIO_LRCK: U2.43; also elsewhere on the board
FPGA_CDONE: J6.2, Q1.1, R63.2, U2.7; also elsewhere on the board
GND: C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C59.1, C60.2, J6.8, Q1.2, R5.1, U2.49, X1.2; also elsewhere on the board
unnamed: J6.1, JP1.2, JP3.2
unnamed: LD2.1 (K), R1.1
unnamed: Q1.3, R1.2
unnamed: R3.2, R4.2, X1.3
SPI_MISO: J6.4, U2.17; also elsewhere on the board
SPI_MOSI: J6.5, U2.14; also elsewhere on the board
SPI_SCK: J6.6, U2.15; also elsewhere on the board
SPI_SSEL_N: J6.7, R62.2, U2.16; also elsewhere on the board
VGA_B0: U2.46; also elsewhere on the board
VGA_B1: U2.47; also elsewhere on the board
VGA_B2: U2.48; also elsewhere on the board
VGA_B3: U2.2; also elsewhere on the board
VGA_G0: U2.3; also elsewhere on the board
VGA_G1: U2.4; also elsewhere on the board
VGA_G2: U2.6; also elsewhere on the board
VGA_G3: U2.9; also elsewhere on the board
VGA_HSYNC: U2.44; also elsewhere on the board
VGA_R0: U2.10; also elsewhere on the board
VGA_R1: U2.11; also elsewhere on the board
VGA_R2: U2.12; also elsewhere on the board
VGA_R3: U2.13; also elsewhere on the board
VGA_VSYNC: U2.45; also elsewhere on the board
VSYSCLK: R3.1, U2.35
mA0: U2.40; also elsewhere on the board
mA1: U2.39; also elsewhere on the board
mA2: U2.37; also elsewhere on the board
mA3: U2.41; also elsewhere on the board
mA4: U2.34; also elsewhere on the board
mD0: U2.27; also elsewhere on the board
mD1: U2.26; also elsewhere on the board
mD2: U2.25; also elsewhere on the board
mD3: U2.23; also elsewhere on the board
mD4: U2.21; also elsewhere on the board
mD5: U2.20; also elsewhere on the board
mD6: U2.19; also elsewhere on the board
mD7: U2.18; also elsewhere on the board
~FPGA_RESET: J6.3, R5.2, U2.8; also elsewhere on the board
~mRE: U2.36; also elsewhere on the board
~mVCS0: U2.28; also elsewhere on the board
~mVIRQ: U2.32; also elsewhere on the board
~mWE: U2.31; also elsewhere on the board

Notes on the sheet:
"VERA READY" Internal LED
25 MHz
FPGA VERA LOGIC VIDEO & AUDIO CARD
VERA FPGA PROGRAMMED OK
iceprog programmer USB FTDI / SPI
ALL SIGNALS MUST BE IN 3.3V RANGE
! NEED ONLY ONE SOLDERED !

Schematic: busdecoder.sch, BUS DECODER

Parts:
C13, C15, C17, C19, C21, C24: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C440198
C14, C16, C18, C20, C22, C23, C61, C63, C67, C68: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C840116
C25: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C2798196
C64, C65: 27pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C1808
L1: FB0805100R100MHZ4A; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C15957
L2: IND0603600R100MHZ300mA; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC C139271
LD1, LD5: RED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C965822
R31, R33, R59, R60: 4K7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17673
R32, R61: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C313892
R36, R53, R65, R70, R71: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C84376
SW1, SW3: SPST2P; SPST-7.3x3.9x2.5-WUERTH-434121025816; LCSC C318911
U5: IC74HC00; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C5586
U7: ESP32-S3FN8; IC_ESP32-S3FN8-QFN40P700X700X90-57N; Manufacturer PN ESP32-S3FN8; LCSC C2913196
U24, U25: SN74LVC00; TSSOP-14_4.4x5mm_P0.65mm; LCSC C7803
Y2: 40.000Mhz; Crystal_SMD_2520-4Pin_2.5x2.0mm; LCSC C284176

Connections:
3V3: C13.1, C14.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.2, C24.2, C63.2, C67.1, C68.1, L1.1, R31.1, R32.1, R33.1, R36.2, R53.2, R59.2, R60.1, R61.1, R65.2, R71.1, U5.14, U7.20, U7.29, U7.46, U7.55, U7.56, U24.14, U25.14; also elsewhere on the board
/BusDecoder/B: U25.3, U25.5
/BusDecoder/VDD3P3: C15.1, C16.1, L1.2, U7.2, U7.3
/BusDecoder/a1: U24.8, U25.1
/BusDecoder/a2: U24.11, U25.2
/BusDecoder/n1: U24.3, U24.9, U24.10
/BusDecoder/n2: U24.6, U24.12, U24.13
BOOT0: C61.1, R33.2, SW3.2, U7.5; also elsewhere on the board
ESP32_CH340_RXD: U7.50; also elsewhere on the board
ESP32_CH340_TXD: U7.49; also elsewhere on the board
FPGA_CDONE: U7.44; also elsewhere on the board
GND: C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.1, C24.1, C25.2, C61.2, C63.1, C64.1, C65.1, C67.2, C68.2, R70.1, SW1.1, SW3.1, U5.7, U5.12, U5.13, U7.57, U24.7, U25.7, U25.9, U25.10, U25.12, U25.13, Y2.2, Y2.4; also elsewhere on the board
unnamed: C64.2, U7.53, Y2.3
unnamed: C65.2, L2.2, Y2.1
unnamed: L2.1, U7.54
unnamed: LD1.2, R32.2
unnamed: LD5.2, R61.2
unnamed: R71.2, U7.8
unnamed: U5.4, U5.8
RST\EN: C25.1, R31.2, SW1.2, U7.4; also elsewhere on the board
mA0: U7.17; also elsewhere on the board
mA1: U7.18; also elsewhere on the board
mA2: U7.19; also elsewhere on the board
mA3: U7.21; also elsewhere on the board
mA4: U7.22; also elsewhere on the board
mA5: U7.23; also elsewhere on the board
mA6: U7.24; also elsewhere on the board
mA7: U7.25; also elsewhere on the board
mA8: U7.26; also elsewhere on the board
mA9: U7.27; also elsewhere on the board
mA10: U7.38; also elsewhere on the board
mA11: U7.39; also elsewhere on the board
mA12: U7.40; also elsewhere on the board
mA13: U7.41; also elsewhere on the board
mA14: U7.51; also elsewhere on the board
mA15: U7.52; also elsewhere on the board
mD0: U7.9; also elsewhere on the board
mD1: U7.10; also elsewhere on the board
mD2: U7.11; also elsewhere on the board
mD3: U7.12; also elsewhere on the board
mD4: U7.13; also elsewhere on the board
mD5: U7.14; also elsewhere on the board
mD6: U7.15; also elsewhere on the board
mD7: U7.16; also elsewhere on the board
mPHI2: U5.1, U5.5, U7.6, U25.4; also elsewhere on the board
mR~W: U5.2, U5.9, U5.10, U7.7, U24.1; also elsewhere on the board
~ABUS_OE: U7.37; also elsewhere on the board
~ATARI_RESET: R70.2, U7.42; also elsewhere on the board
~FPGA_RESET: U7.43; also elsewhere on the board
~OE: U25.6; also elsewhere on the board
~mCCTL: LD1.1; also elsewhere on the board
~mD1XX: LD5.1; also elsewhere on the board
~mEXSEL: R53.1, U7.47, U24.4; also elsewhere on the board
~mMPD: R65.1, U7.48, U24.5; also elsewhere on the board
~mRE: R59.1, U5.3; also elsewhere on the board
~mVCS0: R36.1, U7.45, U24.2; also elsewhere on the board
~mWE: R60.2, U5.6; also elsewhere on the board

Notes on the sheet:
R/W Adapter for RE and WE signals as VERA MODULE wants
When VERA Chip Select (mVCS0) latch is active & A15..A0 $D800-$DFFF -> MPD active (External 2K ROM) When VERA Chip Select (mVCS0) latch is active & A15..A0 $D600-$D7FF -> EXSEL active (External 512 bytes RAM) When access @ $D1xx and VERA Chip Select (mVCS0) latch is active -> EXSEL active
PBI DEVICE ID: software selectable only
Accessing $D5XX area space
ESP32 RESET SWITCH
PBI Bus Interface Decoder: I/O Space, Math Pack Disable, ROM ADDRESS ($D800-$DFFF), RAM PBI SPACE ($D600-$D7FF)
Accessing $D1XX area space
HARDWARE DRIVEN LEDS
ESP32 BOOT SWITCH
ATARI RESET IS ALWAYS ASSERTED WHEN POWERING UP THE MEMORY CONTROLLER
ATARI SIGNALS ARE ALWAYS NOT VALIDATED WHEN POWERING UP THE MEMORY CONTROLLER AND THE SYSTEM CORE

Schematic: cartridgeInterface.sch, CARTRIDGE INTEFACE AND BUS LEVEL SHIFTERS

Parts:
C1, C2, C9, C10, C11, C12, C55, C56, C57, C58, C62, C69: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C840116
C66: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C2798196
CART1: ATARI-CARTRIDGE; ATARI-LEFT-CARTRIDGE
ECI1: ECIBUS; ATARI-XE-ECI-SLOT
R2, R6: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17513
R7, R34, R69: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C84376
R64, R66, R72, R73, R74, R75, R76, R77: CREZ08051%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C328378
RD4, RD5: TestPoint; TestPoint_Pad_D2.0mm
U3, U4, U6, U16, U19: 74LVC4245APW_118; IC_74LVC4245_SOP65P640X110-24N; LCSC C6091
U23: SN74HCT04DR; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C6766
U26: SN74LVC1G07DBVR; SOT-23-5; LCSC C7829
mD1XX1: TestPoint; TestPoint_Pad_D2.0mm
~HALT1: TestPoint; TestPoint_Pad_D2.0mm
~mREF1: TestPoint; TestPoint_Pad_D2.0mm
~mS4, ~mS5: TestPoint; TestPoint_Pad_D2.0mm

Connections:
3V3: C1.2, C9.2, C11.2, C55.2, C58.2, C69.1, R7.2, R34.2, U3.23, U3.24, U4.23, U4.24, U6.23, U6.24, U16.23, U16.24, U19.23, U19.24, U26.5; also elsewhere on the board
5V: C2.2, C10.2, C12.2, C56.2, C57.1, C62.2, CART1.13, ECI1.7, R69.1, U3.1, U3.2, U4.1, U4.2, U6.1, U6.2, U16.1, U19.1, U23.14; also elsewhere on the board
A0: CART1.5, U4.3
A1: CART1.4, U4.4
A2: CART1.3, U4.5
A3: CART1.2, U4.6
A4: CART1.C, U4.7
A5: CART1.D, U4.8
A6: CART1.E, U4.9
A7: CART1.F, U4.10
A8: CART1.H, U3.3
A9: CART1.J, U3.4
A10: CART1.P, U3.5
A11: CART1.N, U3.6
A12: CART1.K, U3.7
A13: ECI1.D, U3.8
A14: ECI1.E, U3.9
A15: ECI1.F, U3.10
AUD1L: R2.2; also elsewhere on the board
AUD1R: R6.2; also elsewhere on the board
AUDIO: C66.1, ECI1.5
D0: CART1.10, U19.3
D1: CART1.9, U19.4
D2: CART1.8, U19.5
D3: CART1.L, U19.6
D4: CART1.6, U19.7
D5: CART1.7, U19.8
D6: CART1.11, U19.9
D7: CART1.M, U19.10
GND: C1.1, C2.1, C9.1, C10.1, C11.1, C12.1, C55.1, C56.1, C57.2, C58.1, C62.1, C69.2, CART1.B, ECI1.H, R64.2, R66.2, R72.1, R73.1, R74.2, R75.1, R76.1, R77.1, U3.11, U3.12, U3.13, U4.11, U4.12, U4.13, U6.11, U6.12, U6.13, U16.11, U16.12, U16.13, U19.11, U19.12, U19.13, U23.3, U23.5, U23.7, U23.9, U23.11, U23.13, U26.3; also elsewhere on the board
unnamed: C66.2, R2.1, R6.1
unnamed: R64.1, U6.22
unnamed: R66.1, U16.2, U16.22
unnamed: R72.2, U16.14
unnamed: R73.2, U16.19
unnamed: R74.1, U6.10
unnamed: R75.2, U16.15
unnamed: R76.2, U16.20
unnamed: R77.2, U16.21
unnamed: U19.2, U23.2
PHI2: CART1.S, U6.7
RD4: CART1.A, RD4.1
RD5: CART1.14, RD5.1
R~W: CART1.R, R69.2, U6.6, U23.1
mA0: U4.21; also elsewhere on the board
mA1: U4.20; also elsewhere on the board
mA2: U4.19; also elsewhere on the board
mA3: U4.18; also elsewhere on the board
mA4: U4.17; also elsewhere on the board
mA5: U4.16; also elsewhere on the board
mA6: U4.15; also elsewhere on the board
mA7: U4.14; also elsewhere on the board
mA8: U3.21; also elsewhere on the board
mA9: U3.20; also elsewhere on the board
mA10: U3.19; also elsewhere on the board
mA11: U3.18; also elsewhere on the board
mA12: U3.17; also elsewhere on the board
mA13: U3.16; also elsewhere on the board
mA14: U3.15; also elsewhere on the board
mA15: U3.14; also elsewhere on the board
mD0: U19.21; also elsewhere on the board
mD1: U19.20; also elsewhere on the board
mD2: U19.19; also elsewhere on the board
mD3: U19.18; also elsewhere on the board
mD4: U19.17; also elsewhere on the board
mD5: U19.16; also elsewhere on the board
mD6: U19.15; also elsewhere on the board
mD7: U19.14; also elsewhere on the board
mPHI2: U6.17; also elsewhere on the board
mREFRESH: U6.15
mR~W: U6.18; also elsewhere on the board
~ABUS_OE: R7.1, R34.1, U3.22, U4.22; also elsewhere on the board
~ATARI_RESET: U16.16; also elsewhere on the board
~CCTL: CART1.15, U6.8
~D1XX: ECI1.3, U6.3
~EXSEL: ECI1.1, U16.6
~HALT: ECI1.C
~IRQ: ECI1.B, U26.4
~MPD: ECI1.4, U16.7
~OE: U19.22; also elsewhere on the board
~REFRESH: ECI1.6, U6.9
~RST: ECI1.2, U16.8
~S4: CART1.1, U6.4
~S5: CART1.12, U6.5
~mCCTL: U6.16; also elsewhere on the board
~mD1XX: U6.21, mD1XX1.1; also elsewhere on the board
~mEXSEL: U16.18; also elsewhere on the board
~mMPD: U16.17; also elsewhere on the board
~mS4: U6.20
~mS5: U6.19
~mVIRQ: U26.2; also elsewhere on the board

Notes on the sheet:
ATARI 130XE ECI & CARTRIDGE INTERFACE
AUDIO MIXER INSIDE ATARI
All 8-Bit signals must be shifted from 5V to 3.3V and vice versa
UNCONNECTED IN THIS PROJECT
BUS LOGIC LEVEL SHIFTERS
DIRECTION 6502 --> MCU
DIRECTION MCU --> 6502
BIDIRECTIONAL 6502 <---> MCU
CONTROL SIGNALS
ADDRESS BUS
DATA BUS
Interrupt Setup between VERA & CPU

Schematic: vera-fpga-flash.sch, uSD Card, FPGA FLASH and AUDIO SECTION

Parts:
C26, C34, C35: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C7393930
C27, C28, C29, C52: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C840116
C30, C31, C32, C33: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C2798196
C36: 2.2uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C377773
J3: CONN_DM3AT-SF-PEJM5; HRS_DM3AT-SF-PEJM5; PARTREV 20200913; LCSC C114218
J7: SJ-3523-SMT-TR; CONN_AUDIO_CUI_SJ-3523-SMT-TR; LCSC C4991872
JP2: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
R35: CREZ08051%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C328378
R37, R38, R39, R40, R41, R42, R43, R44: 47K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17713
R45, R46, R67, R68: 560R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C28636
U8: 74CBTLV3126PW,118; TSSOP-14_4.4x5mm_P0.65mm; LCSC C543078
U9: CD4011B; SOIC-14_3.9x8.7mm_P1.27mm; LCSC C194334
U10: W25Q16JVSNIQ; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C2456211
U11: WM8524CGEDT; TSSOP-16_4.4x5mm_P0.65mm; LCSC C146242

Connections:
3V3: C26.1, C27.1, C28.1, C29.1, C34.1, C35.1, J3.4, R35.1, R37.1, R38.1, R39.1, R40.1, R41.1, R43.1, R44.1, U8.14, U9.14, U10.8, U11.6, U11.15; also elsewhere on the board
/Vera FPGA flash/CLK: J3.5, R42.1, U8.8
/Vera FPGA flash/CMD: J3.3, R37.2, U8.6
/Vera FPGA flash/DAT0: J3.7, R40.2, U8.11
/Vera FPGA flash/DAT1: J3.8, R41.2
/Vera FPGA flash/DAT2: J3.1, R39.2
/Vera FPGA flash/DAT3: J3.2, R38.2, U8.3
/Vera FPGA flash/FLASH_SSEL_N: U9.11, U10.1
/Vera FPGA flash/SD_SSEL_N: U8.2, U9.10
ASYSCLK: U11.10; also elsewhere on the board
AUD1L: J7.3, R67.1; also elsewhere on the board
AUD1R: J7.2, R68.1; also elsewhere on the board
AUDIO_BCK: U11.9; also elsewhere on the board
AUDIO_DATA: U11.7; also elsewhere on the board
AUDIO_LRCK: U11.8; also elsewhere on the board
FPGA_CDONE: JP2.2, U8.1, U8.4, U8.10, U8.13, U9.1, U9.2, U9.8; also elsewhere on the board
GND: C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C35.2, C36.2, C52.2, J3.6, J7.1, JP2.1, R42.2, U8.7, U9.7, U10.4, U11.4, U11.13; also elsewhere on the board
unnamed: C30.1, R46.1, R68.2
unnamed: C31.1, R45.1, R67.2
unnamed: C32.1, U11.5
unnamed: C32.2, U11.3
unnamed: C33.1, U11.2
unnamed: C36.1, U11.14
unnamed: C52.1, J3.SH
unnamed: R35.2, U11.11, U11.12
unnamed: R43.2, U10.3
unnamed: R44.2, U10.7
unnamed: R45.2, U11.1
unnamed: R46.2, U11.16
unnamed: U9.3, U9.12
unnamed: U9.4, U9.9, U9.13
SPI_MISO: U8.12, U10.2; also elsewhere on the board
SPI_MOSI: U8.5, U10.5; also elsewhere on the board
SPI_SCK: U8.9, U10.6; also elsewhere on the board
SPI_SSEL_N: U9.5, U9.6; also elsewhere on the board

Notes on the sheet:
IC DAC/AUDIO 24BIT 192K 16TSSOP
SD/microSD INTERFACE
FPGA/SSD Flash Glue Logic
SPI 16MB FLASH
The microSD BUS will be available only when FPGA is ready and programmed
When programming SPI FLASH for bitstream, the JP2 jumper must be closed. Should be open in a normal operational mode.
AUDIO 3.5mm OUTPUT
AUDIO SECTION

Schematic: powersupply.sch, POWERSUPPLY and USB

Parts:
C37: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C86817
C38, C40, C42, C44, C46, C49, C50: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C840116
C39, C41: 20pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C376875
C43: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C2798196
C45, C48, C51: 10uF-20V; CP_EIA-3528-12_Kemet-T_Pad1.50x2.35mm_HandSolder; LCSC C8017
C47: 10uF-35V; CP_EIA-3528-12_Kemet-T_Pad1.50x2.35mm_HandSolder; LCSC C8017
D3, D4: DIOSCH20V; D_SMC_Handsoldering; LCSC C236151
J4: DX07S016JA1R1500; JAE_DX07S016JA1R1500; PARTREV 1; LCSC C3197885
J5: PJ-002AH-SMT-TR; CUI_PJ-002AH-SMT-TR; LCSC C22434687
LD3: RED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC C965822
LD4: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; LCSC C84260
Q3, Q4: BC817,SOT-23; SOT-23; LCSC C20069154
R47, R48: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C84376
R49: DNP; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R50, R51: 5K1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C27834
R52, R55: 2K2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17520
R54: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C5120092
R56: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C328378
R57: 510R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C114563
R58: 330R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C105881
TP1: TP5V; TestPoint_Pad_D2.0mm
U12: USBCH340T; SSOP-20_5.3x7.2mm_P0.65mm; LCSC C8689
U13: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186
U14: AMS1117-1.2; SOT-223-3_TabPin2; LCSC C347218
U15: L7805; TO-252-2; LCSC C110908
U17, U18: MAX40200AUK; SOT-23-5; LCSC C47118006
Y1: 12MHzC; Crystal_SMD_EuroQuartz_MT-4Pin_3.2x2.5mm; LCSC C9002

Connections:
1V2: C43.1, C51.1, U14.2; also elsewhere on the board
3V3: C45.1, C46.1, LD4.2 (A), R49.2, U13.2; also elsewhere on the board
5V: C37.1, C44.1, C50.1, LD3.2, R47.2, TP1.1, U12.19, U13.3, U14.3, U17.5, U18.5; also elsewhere on the board
/PowerSupply/D+: J4.6, J4.7, U12.6
/PowerSupply/D-: J4.5, J4.8, U12.7
BOOT0: R54.1; also elsewhere on the board
ESP32_CH340_RXD: D3.2, R48.2, R49.1; also elsewhere on the board
ESP32_CH340_TXD: D4.1; also elsewhere on the board
GND: C37.2, C38.2, C39.1, C40.2, C41.1, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, J4.1, J4.12, J5.2, R50.2, R51.2, R57.2, R58.2, U12.8, U13.1, U14.1, U15.2, U17.2, U18.2, Y1.2, Y1.4; also elsewhere on the board
unnamed: C38.1, R48.1, U12.5
unnamed: C39.2, U12.9, Y1.1
unnamed: C40.1, J4.2, J4.11, U18.1, U18.3
unnamed: C41.2, U12.10, Y1.3
unnamed: C42.1, J4.S1, J4.S2, J4.S3, J4.S4, J4.S5, J4.S6
unnamed: C47.1, J5.1A, J5.1B, U15.1
unnamed: C48.1, C49.1, R56.2, U15.3
unnamed: D3.1, U12.3
unnamed: D4.2, R47.1, U12.4
unnamed: J4.3, R50.1
unnamed: J4.9, R51.1
unnamed: LD3.1, R57.1
unnamed: LD4.1 (K), R58.1
unnamed: Q3.1, R52.1
unnamed: Q3.2, R55.2, U12.16
unnamed: Q4.1, R55.1
unnamed: Q4.2, R52.2, U12.15
unnamed: Q4.3, R54.2
unnamed: R56.1, U17.1, U17.3
RST\EN: Q3.3; also elsewhere on the board

Notes on the sheet:
POWER INPUT: from 5VDC...24VDC Positive CENTRAL PIN
USB ESP32 PROGRAMMING
POWER 3.3V & POWER 1.2V
POWER LED 5V: RED 3.3V: GREEN
Differential Pairs 90 Ohm
Double Powering Protection Diode

Schematic: vga-analog.sch, VGA ANALOG AND EXTERNAL VIDEO CONNECTOR

Parts:
C53, C54: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; LCSC C840116
J1: CONN_SMD_HEADER_BOX_02x08_Odd_Even_2.54mm; PinHeader_BOX_2x08_P2.54mm_Vertical_SMD; LCSC C2685064
J2: DS1038-15FBNSiA74-0CC; CONNFLY_DS1038-15FBNSIA74-0CC; LCSC C75754
R8, R9, R10: 4K3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17667
R11, R13, R15: 2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C114572
R12, R14, R16: 150R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17471
R17, R19, R21: 910R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C2930211
R18, R20, R22: 160R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C2960793
R23, R25, R27: 510R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C114563
R24, R26, R28: 27R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17594
R29, R30: 820R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; LCSC C17837

Connections:
3V3: J1.4, J1.16; also elsewhere on the board
5V: J1.9, J1.15, J2.9; also elsewhere on the board
AUD1L: J1.11; also elsewhere on the board
AUD1R: J1.12; also elsewhere on the board
GND: C53.1, C54.1, J1.5, J1.6, J1.7, J1.8, J1.10, J2.5, J2.6, J2.7, J2.8, J2.10; also elsewhere on the board
unnamed: C53.2, J2.S2
unnamed: C54.2, J2.S1
unnamed: R11.1, R12.2
unnamed: R13.1, R14.2
unnamed: R15.1, R16.2
unnamed: R17.1, R18.2
unnamed: R19.1, R20.2
unnamed: R21.1, R22.2
unnamed: R23.1, R24.2
unnamed: R25.1, R26.2
unnamed: R27.1, R28.2
VGABLUE: J1.3, J2.3, R8.1, R12.1, R18.1, R24.1
VGAGREEN: J1.2, J2.2, R9.1, R14.1, R20.1, R26.1
VGAHSYNC: J1.13, J2.13, R29.1
VGARED: J1.1, J2.1, R10.1, R16.1, R22.1, R28.1
VGAVSYNC: J1.14, J2.14, R30.1
VGA_B0: R8.2; also elsewhere on the board
VGA_B1: R11.2; also elsewhere on the board
VGA_B2: R17.2; also elsewhere on the board
VGA_B3: R23.2; also elsewhere on the board
VGA_G0: R9.2; also elsewhere on the board
VGA_G1: R13.2; also elsewhere on the board
VGA_G2: R19.2; also elsewhere on the board
VGA_G3: R25.2; also elsewhere on the board
VGA_HSYNC: R29.2; also elsewhere on the board
VGA_R0: R10.2; also elsewhere on the board
VGA_R1: R15.2; also elsewhere on the board
VGA_R2: R21.2; also elsewhere on the board
VGA_R3: R27.2; also elsewhere on the board
VGA_VSYNC: R30.2; also elsewhere on the board

Notes on the sheet:
EXTERNAL DISPLAY WITH AUDIO
ANALOG VGA SIGNALS
EXTERNAL VIDEO CONNECTOR

Notices in the files:
README.md:
├── 📄 LICENSE # Licenza GPL v3
Questo progetto è licenziato sotto la **GNU General Public License v3.0**.
